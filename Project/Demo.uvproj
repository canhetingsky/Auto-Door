# Keil uVision project Demo.uvproj, settings and files
target Automatic Door (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Lib\CORE;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\User\app\inc;..\User\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../Lib/CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FWLIB
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group APP
    ../User/app/src/: main.c
  group BSP
    ../User/app/src/: stm32f4xx_it.c
    ../User/bsp/src/: bluetooth.c pwm.c systick.c rgb.c infrare.c led.c
  group NOTE
    ../Note/: LOG.md
